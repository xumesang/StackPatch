# IAR project Project.ewp, settings and files
configuration PLC01A1_OUT01A1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; USE_STM32F4XX_NUCLEO; USART_PRINT_MSG; PLC01A1_OUT01A1
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO\X-NUCLEO-PLC01A1; ..\..\..\..\..\..\Drivers\BSP\Components\CLT01-38SQ7; ..\..\..\..\..\..\Middlewares\ST\STM32_LADDER_LIBRARY; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\BSP\Components\Common\PLC01; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Utils; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO\X-NUCLEO-OUT01A1; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO\X-NUCLEO-IDW01M1; ..\..\..\..\..\..\Drivers\BSP\Components\ISO8200BQ; ..\..\..\..\..\..\Drivers\BSP\Components\VNI8200XP; ..\..\..\..\..\..\Drivers\BSP\Components\Common\OUT01
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PLC01A1_OUT01A1.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration PLC01A1 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; USE_STM32F4XX_NUCLEO; USART_PRINT_MSG; PLC01A1
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO\X-NUCLEO-IDW01M1; ..\..\..\..\..\..\Drivers\BSP\Components\VNI8200XP; ..\..\..\..\..\..\Middlewares\ST\STM32_LADDER_LIBRARY; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\BSP\Components\Common\PLC01; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Utils; ..\..\..\..\..\..\Drivers\BSP\Components\Common\OUT01; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO\X-NUCLEO-OUT01A1; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO\X-NUCLEO-PLC01A1; ..\..\..\..\..\..\Drivers\BSP\Components\VNI8200XP; ..\..\..\..\..\..\Drivers\BSP\Components\ISO8200BQ; ..\..\..\..\..\..\Drivers\BSP\Components\CLT01-38SQ7
  OBJCOPY.OOCOutputFile: PLC01A1.hex
configuration OUT01A1 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; USE_STM32F4XX_NUCLEO; USART_PRINT_MSG; OUT01A1
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO\X-NUCLEO-PLC01A1; ..\..\..\..\..\..\Drivers\BSP\Components\VNI8200XP; ..\..\..\..\..\..\Middlewares\ST\STM32_LADDER_LIBRARY; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\BSP\Components\Common\PLC01; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Utils; ..\..\..\..\..\..\Drivers\BSP\Components\Common\OUT01; ..\..\..\..\..\..\Drivers\BSP\Components\CLT01-38SQ7; ..\..\..\..\..\..\Drivers\BSP\Components\ISO8200BQ; ..\..\..\..\..\..\Drivers\BSP\Components\VNI8200XP; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO\X-NUCLEO-OUT01A1; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO\X-NUCLEO-IDW01M1
  OBJCOPY.OOCOutputFile: OUT01A1.hex
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/CLT01-38SQ7/: CLT01_38S.c
    ../../../../../../Drivers/BSP/Components/ISO8200BQ/: ISO8200BQ.c
    ../../../../../../Drivers/BSP/Components/VNI8200XP/: VNI8200XP.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO
    ../../../../../../Drivers/BSP/X-NUCLEO/X-NUCLEO-IDW01M1/: stm32_spwf_wifi.c
    ../../../../../../Drivers/BSP/X-NUCLEO/X-NUCLEO-OUT01A1/: X_NUCLEO_01A1.c
    ../../../../../../Drivers/BSP/X-NUCLEO/X-NUCLEO-PLC01A1/: X_NUCLEO_PLC01A1.c
  group Drivers/CMSIS
    ../../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group Example/EWARM
    ./: startup_stm32f401xe.s
  group Example/User
    ../../Src/: console.c main.c PLC_Handling.c stm32_xx_hal_msp.c stm32_xx_it.c
  group Middlewares/STM32_LADDER_LIBRARY
    ../../../../../../Middlewares/ST/STM32_LADDER_LIBRARY/: Ladder_Lib.c
  group Middlewares/STM32_SPWF01SA
    ../../../../../../Middlewares/ST/STM32_SPWF01SA/: wifi_interface.c wifi_module.c
  group Middlewares/STM32_SPWF01SA/Utils
    ../../../../../../Middlewares/ST/STM32_SPWF01SA/Utils/: event_buffer.c ring_buffer.c wifi_globals.c
