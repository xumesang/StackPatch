# Keil uVision project Project.uvprojx, settings and files
target PLC01A1_OUT01A1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: PLC01A1_OUT01A1 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,USART_PRINT_MSG,PLC01A1_OUT01A1
  c misc: --C99
  c include: ../../Inc;../../../../../../Middlewares/ST/STM32_SPWF01SA;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F4xx-Nucleo;../../../../../../Drivers/BSP/X-NUCLEO/X-NUCLEO-PLC01A1;../../../../../../Drivers/BSP/Components/CLT01-38SQ7;../../../../../../Middlewares/ST/STM32_LADDER_LIBRARY;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/Components/Common/PLC01;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/ST/STM32_SPWF01SA/Inc;../../../../../../Middlewares/ST/STM32_SPWF01SA/Utils;../../../../../../Drivers/BSP/X-NUCLEO/X-NUCLEO-OUT01A1;../../../../../../Drivers/BSP/X-NUCLEO/X-NUCLEO-IDW01M1;../../../../../../Drivers/BSP/Components/ISO8200BQ;../../../../../../Drivers/BSP/Components/VNI8200XP;../../../../../../Drivers/BSP/Components/Common/OUT01
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ISO8200BQ/: ISO8200BQ.c
    ../../../../../../Drivers/BSP/Components/VNI8200XP/: VNI8200XP.c
    ../../../../../../Drivers/BSP/Components/CLT01-38SQ7/: CLT01_38S.c
  group Drivers/BSP/X-NUCLEO
    ../../../../../../Drivers/BSP/X-NUCLEO/X-NUCLEO-PLC01A1/: X_NUCLEO_PLC01A1.c
    ../../../../../../Drivers/BSP/X-NUCLEO/X-NUCLEO-OUT01A1/: X_NUCLEO_01A1.c
    ../../../../../../Drivers/BSP/X-NUCLEO/X-NUCLEO-IDW01M1/: stm32_spwf_wifi.c
  group Middlewares/STM32_SPWF01SA
    ../../../../../../Middlewares/ST/STM32_SPWF01SA/: wifi_module.c wifi_interface.c
  group Drivers/CMSIS
    ../../Src/: system_stm32f4xx.c
  group Example/User
    ../../Src/: stm32_xx_hal_msp.c main.c stm32_xx_it.c console.c PLC_Handling.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_cortex.c stm32f4xx_hal_usart.c
  group Example/MDK-ARM
    ./: startup_stm32f401xe.s
  group Middlewares/STM32_SPWF01SA/Utils
    ../../../../../../Middlewares/ST/STM32_SPWF01SA/Utils/: event_buffer.c ring_buffer.c wifi_globals.c
  group Middlewares/STM32_LADDER_LIBRARY
    ../../../../../../Middlewares/ST/STM32_LADDER_LIBRARY/: Ladder_Lib.c
target PLC01A1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: as above
  output: PLC01A1
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,USART_PRINT_MSG,PLC01A1
  c misc: --C99
  c include: ../../Inc;../../../../../../Middlewares/ST/STM32_SPWF01SA;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F4xx-Nucleo;../../../../../../Drivers/BSP/X-NUCLEO/X-NUCLEO-IDW01M1;../../../../../../Drivers/BSP/Components/VNI8200XP;../../../../../../Middlewares/ST/STM32_LADDER_LIBRARY;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/Components/Common/PLC01;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/ST/STM32_SPWF01SA/Inc;../../../../../../Middlewares/ST/STM32_SPWF01SA/Utils;../../../../../../Drivers/BSP/Components/Common/OUT01;../../../../../../Drivers/BSP/X-NUCLEO/X-NUCLEO-OUT01A1;../../../../../../Drivers/BSP/X-NUCLEO/X-NUCLEO-PLC01A1;../../../../../../Drivers/BSP/Components/VNI8200XP;../../../../../../Drivers/BSP/Components/ISO8200BQ;../../../../../../Drivers/BSP/Components/CLT01-38SQ7
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
target OUT01A1 (ARM-ADS)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: as above
  output: OUT01A1 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,USART_PRINT_MSG,OUT01A1
  c misc: --C99
  c include: ../../Inc;../../../../../../Middlewares/ST/STM32_SPWF01SA;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F4xx-Nucleo;../../../../../../Drivers/BSP/X-NUCLEO/X-NUCLEO-PLC01A1;../../../../../../Drivers/BSP/Components/VNI8200XP;../../../../../../Middlewares/ST/STM32_LADDER_LIBRARY;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/Components/Common/PLC01;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/ST/STM32_SPWF01SA/Inc;../../../../../../Middlewares/ST/STM32_SPWF01SA/Utils;../../../../../../Drivers/BSP/Components/Common/OUT01;../../../../../../Drivers/BSP/Components/CLT01-38SQ7;../../../../../../Drivers/BSP/Components/ISO8200BQ;../../../../../../Drivers/BSP/Components/VNI8200XP;../../../../../../Drivers/BSP/X-NUCLEO/X-NUCLEO-OUT01A1;../../../../../../Drivers/BSP/X-NUCLEO/X-NUCLEO-IDW01M1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
software components: CMSIS:CORE 4.3.0
